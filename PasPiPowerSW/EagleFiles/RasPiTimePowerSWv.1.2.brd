# Repository haya-sann/kawagoe

File README.md:

# kawagoe-電源回路基板
ホストマシンの電源を指定時間遮断する回路基板<BR>
電源を遮断（deepSleep）させる時間はホストマシンからI2Cで指定する

## EAGLE design PasPiPowerSW/EagleFiles/RasPiTimePowerSWv.1.2.brd

Parts:
C1: 20μF 16V; C075-042X103
C2, C3: 1nF(102); C025-024X044
C4: 0.1μF(104); C025-024X044
C5: 0.33μF; C025-024X044
IC1: MSP430G2553; SOCKET-20
IC2: NJM2845DL1-33; TO252
JP1: PINHD-1X4; 1X04
LED1, LED2: TLLG4400; LED3MM
Q1: P-ch MOS FET; SOT23
R1, R2, R3, R5, R6: R-US_MELF0102W; MINI_MELF-0102W
R4: 47kΩ; MINI_MELF-0102W
RESET: 9450-1
S1: 255SB
SV1: MA12-2
T1: 2SC1815-Y; TO92-ECB
USB-POWER-IN: USB Micro; 32005-400

Connections:
3.3V: C1.1, C3.1, C4.1, IC1.1, IC2.2 (VO), JP1.1, R4.1
5V: Q1.3 (D), SV1.2
5VIN: C5.2, IC2.1 (VI), Q1.2 (S), R2.2, USB-POWER-IN.1
GND: C1.2, C2.2, C3.2, C4.2, C5.1, IC1.20, IC2.3 (GND), JP1.2, LED1.K (C), R6.1, RESET.2, S1.2, SV1.6, T1.E, USB-POWER-IN.5
unnamed: R1.2, T1.B
unnamed: IC1.13, R1.1
unnamed: IC1.2, R3.2
unnamed: R5.1, S1.1 (O)
unnamed: Q1.1 (G), R2.1, T1.C
unnamed: LED1.A, R3.1
unnamed: R5.2, SV1.16
unnamed: LED2.A, SV1.18
unnamed: LED2.K (C), R6.2
RESET: C2.1, IC1.16, R4.2, RESET.1 (S)
SCL: IC1.14, JP1.3, SV1.5
SDA: IC1.15, JP1.4, SV1.3

Notes on the sheet:
Voltage Regulator -3.3v
IRLML6402
1-G
3-D
2-S
1-5V
3-Out
2-GND
NJM2845DL1-33
R3はLEDが暗い場合はもっと小さく。 40〜100Ωでもいい
Raspberry Pi connector
【安定化対策】 C1の容量を大きめのものに変更（最低推奨値は2.2μF。47μFくらいがいい？） C4を追加。ICソケットの足に直結 C5を三端子レギュレーターの入力側に追加（NJM2845の推奨値は0.33μF）

Board: 2 copper layers, 37.8 x 39.4 mm, 22 parts (4 on the bottom side), 16 nets.

## EAGLE design PasPiPowerSW/EagleFiles/RasPiTimePowerSWv.1.6.brd

Board: 2 copper layers, 72.1 x 39.4 mm, 28 parts (14 on the bottom side), 20 nets.

Parts:
C1: 47μF 16V; 153CLV-0605
C2, C3: 1nF(102); C025-024X044
C4, C6, C8: 0.1μF(104); C025-024X044
C5: 0.33μF; C025-024X044
C7: 47μF 16V; C075-042X103
I2C: 1X04
IC1: MSP430G2553; SOCKET-20
IC2: NJM2845DL1-33; TO252
J1: 3P Socket; 6410-03
JP1: 1X02
LED1: LED3MM
LED2: TLLG4400; LED3MM
Q1: P-ch MOS FET; SOT23
R1, R2, R3, R5, R6: MINI_MELF-0102W
R4, R11: 10kΩ; MINI_MELF-0102W
RESET: Reset SW; 9450-1
S1: program switch; 255SB
SV1: MA12-2
SV3: MA03-1
T1: 2SC1815-Y; TO92-ECB

Connections:
3.3V: C1.+, C3.1, C4.1, I2C.1, IC1.1, IC2.2, R4.1, R11.1, SV1.1
5V: C7.1, C8.1, Q1.3, SV1.2
5VIN: C5.2, C6.1, IC2.1, JP1.1, Q1.2, R2.2
GND: C1.-, C2.2, C3.2, C4.2, C5.1, I2C.2, IC1.20, IC2.3, J1.2, JP1.2, R6.1, S1.2, SV1.9, SV1.20, T1.E
unnamed: R1.2, T1.B
unnamed: IC1.13, R1.1
unnamed: R5.2, SV1.16
unnamed: IC1.2, R3.2
unnamed: R5.1, R11.2, S1.1
unnamed: C6.2, Q1.1, R2.1, T1.C
unnamed: C7.2, C8.2, SV1.6
unnamed: LED2.A, SV1.18
unnamed: LED2.K, R6.2
unnamed: RESET.1, SV3.3
unnamed: LED1.A, SV3.1
unnamed: LED1.K, RESET.2, SV3.2
unnamed: J1.1, R3.1
RESET: C2.1, IC1.16, J1.3, R4.2
SCL: I2C.3, IC1.14, SV1.5
SDA: I2C.4, IC1.15, SV1.3

## EAGLE design PasPiPowerSW/EagleFiles/VoltSensor.brd

Board: 2 copper layers, 42.9 x 21.6 mm, 6 parts (0 on the bottom side), 5 nets.

Parts:
A: to ADS1015 A0,A1; 22-23-2021
PROVE: JP2
R1: 100kΩ; M1206
R2: 510kΩ; M1206
R3: 100kΩ; M1206
R4: 510kΩ; M1206

Connections:
unnamed: A.1, R3.2, R4.1
unnamed: A.2, R1.2, R2.1
unnamed: PROVE.1, R4.2
unnamed: PROVE.2, R2.2
PE: PROVE.3, R1.1, R3.1

## EAGLE design PasPiPowerSW/RasPiTimePowerSW_WithSTTS751.brd

Board: 2 copper layers, 34.0 x 44.4 mm, 15 parts (0 on the bottom side), 12 nets.

Parts:
C1: C075-042X103
C2: 1nF(102); C025-024X044
IC1: MSP430G2553; SOCKET-20
IC2: NJM2391; TO252
IC3: STTS751; DIL06
J2, J3: 22-27-2051-05; 6410-05
LED1: _T679-E1F1-1; PLCC2
Q1: P-ch MOS FET; SOT23
R1, R2, R3: M1206
R4: 10kΩ; M1206
T1: 2SC1815; TO92-ECB
X3: USB Micro; 32005-400

Connections:
GND: C1.2, C2.2, IC1.20, IC2.3, IC3.1, IC3.2, IC3.5, J2.3, R3.1, T1.E, X3.5
unnamed: R1.2, T1.B
unnamed: C1.1, IC1.1, IC2.2, IC3.3, R4.1
unnamed: IC1.14, IC3.4, J3.3
unnamed: IC1.15, IC3.6, J3.2
unnamed: IC1.13, R1.1
unnamed: Q1.1, R2.1, T1.C
unnamed: IC1.2, LED1.A
unnamed: LED1.C, R3.2
unnamed: C2.1, R4.2
unnamed: J2.1, Q1.3
unnamed: IC2.1, Q1.2, R2.2, X3.1

## Commit log

2017-08-24 Iotセンサーからのデータを受け取るプログラムのinitial commit
2017-08-24 //This is test line for git update
2017-08-24 2度めの更新テスト
2017-08-24 更新のテスト
2017-10-02 restartProject On High Sierra
2017-10-02 Replaced TO-252 Voltage Regulator part
2017-10-03 revert to NJM2845DL1
2017-10-03 Revert "revert to NJM2845DL1"
    This reverts commit ec86f7a8aa55efb6e9586fa3a205028523492dc4.
2018-02-27 Version 2 finished
