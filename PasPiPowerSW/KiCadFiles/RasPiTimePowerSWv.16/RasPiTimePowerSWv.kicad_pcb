# Repository haya-sann/kawagoe

File README.md:

# kawagoe-電源回路基板
ホストマシンの電源を指定時間遮断する回路基板<BR>
電源を遮断（deepSleep）させる時間はホストマシンからI2Cで指定する

## KiCad design PasPiPowerSW/KiCadFiles/RasPiTimePowerSWv.16/RasPiTimePowerSWv.kicad_pcb

Parts:
C1: 0.33μF; C_0805_HandSoldering
C2, C5: 1nF(102); C_0805_HandSoldering
C3, C8: 47μF 16V; CP_Elec_6.3x5.3
C4: 0.1μF(104); C_0805_HandSoldering
C6, C7: 0.1μF; C_0805_HandSoldering
D1, D2: LED; LED_0805
I2C1: PINHD-1X4; Pin_Header_Angled_1x04_Pitch2.54mm
IC1: MSP430G2553; DIP-20_W7.62mm_LongPads
J1: Conn_01x03_Female
J2: Conn_01x03_Male; Molex_KK-6410-03_03x2.54mm_Straight
JP1: PINHD-1X2; Pin_Header_Angled_1x02_Pitch2.54mm
Q1: 2SC1815; TO-92_Molded_Narrow
Q2: P-ch MOS FET
R1: 200Ω; R_0805_HandSoldering
R2, R3, R6, R7: 10kΩ; R_0805_HandSoldering
R4: 23.5kΩ; R_0805_HandSoldering
R5: R; R_0805_HandSoldering
RESET1: Reset SW; Push_E-Switch_KS01Q01
S1: program switch; SW_CuK_JS202011AQN_DPDT_Angled
SV2: MA12-2; Pin_Header_Straight_2x12_Pitch2.54mm
U1: NJM2845DL1-33; TO-252-2

Connections:
+5V: C1.1, C6.1, JP1.1, Q2.2 (S), R4.1, U1.1 (VI)
/3.3V: C2.1, C3.1, C4.1, I2C1.1, IC1.1, R2.1, R7.1, SV2.1, U1.3 (VO)
/SCL: I2C1.3, IC1.14, SV2.5
/SDA: I2C1.4, IC1.15, SV2.3
G: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, D2.1 (K), I2C1.2, IC1.20, J1.2, J2.2, JP1.2, Q1.1 (E), R5.2, RESET1.2, S1.2, SV2.6, SV2.9, SV2.14, SV2.20, U1.2 (GND)
HeartBeatMonitor: D2.2 (A), J1.3, J2.3, R1.2
unnamed: C6.2, Q1.2 (C), Q2.1 (G), R4.2
unnamed: C7.1, C8.1, Q2.3 (D), SV2.2
unnamed: D1.1 (K), R5.1
unnamed: D1.2 (A), SV2.18
unnamed: IC1.2, R1.1
unnamed: IC1.13, R3.2
unnamed: Q1.3 (B), R3.1
unnamed: R6.1, SV2.16
unnamed: R6.2, R7.2, S1.1 (O)
RST: C5.1, IC1.16, J1.1, J2.1, R2.2, RESET1.1 (S)

Notes on the sheet:
Voltage Regulator -3.3v
IRLML6402
1-G
3-D
2-S
1-5V
3-Out
2-GND
NJM2845DL1-33
R3はLEDが暗い場合はもっと小さく。 40〜100Ωでもいい
Raspberry Pi connector
【安定化対策】 C1の容量を大きめのものに変更（最低推奨値は22μF。実際には47μFくらいがいい？） C4を追加。ICソケットの足に直結 C5を三端子レギュレーターの入力側に追加（NJM2845の推奨値は0.33μF）
電圧測定プローブをI2Cの4Ch ADC、ADS1015に変更-V.1.6 ADS1015を含めて、I2Cバスの先に装着する
注）Raspbery Piは本体側 6、9、14、20、25、30、34、39 がグランドに落ちている。 したがって、GNDはどれか1本を結線する
R4は推奨値は47kΩだが、実際にはそれでは動かなかった。 10kΩくらいでないとだめ。
LED2はローカル開発時の状態表示
電圧測定プローブをI2Cの4Ch ADC、ADS1015に変更-V.1.6 ADS1015を含めて、I2Cバスの先に装着する
外部I2Cセンサー ［温度、湿度、気圧、照度］
What was this line for?

Board: 2 copper layers, 26 parts (1 on the bottom side), 16 nets, no tracks yet.

## Commit log

2017-08-24 Iotセンサーからのデータを受け取るプログラムのinitial commit
2017-08-24 //This is test line for git update
2017-08-24 2度めの更新テスト
2017-08-24 更新のテスト
2017-10-02 restartProject On High Sierra
2017-10-02 Replaced TO-252 Voltage Regulator part
2017-10-03 revert to NJM2845DL1
2017-10-03 Revert "revert to NJM2845DL1"
    This reverts commit ec86f7a8aa55efb6e9586fa3a205028523492dc4.
2018-02-27 Version 2 finished
